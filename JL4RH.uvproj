# Keil uVision project JL4RH.uvproj, settings and files
target JL4RH (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: NANO102LC2AN Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x7FFF) CLOCK(32000000) CPUTYPE("Cortex-M0")
  output: JL4RH +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Library\CMSIS\Include;.\Library\Device\Nuvoton\Nano1X2Series\Include;.\Library\StdDriver\inc;.\Library\LCDLib\Include;.\SRC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_Nano1X2Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./Library/Device/Nuvoton/Nano1X2Series/Source/: system_Nano1X2Series.c
    ./Library/Device/Nuvoton/Nano1X2Series/Source/ARM/: startup_Nano1X2Series.s
  group User
    ./SRC/: T_Dew_table.c main.c conneco_ble.c key_scan.c
  group Libraries
    ./Library/StdDriver/src/: sys.c adc.c timer.c clk.c pwm.c rtc.c spi.c pdma.c
